# Repository Nero-198/DDS-Controller_with_AD9852

## KiCad design AD9852_testBoard/AD9852.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 100n; C_0603_1608Metric
IC1: AD9852ASVZ; QFP65P1600X1600X120-81N; Manufacturer_Part_Number AD9852ASVZ
J1, J2, J3, J4: Conn_01x20_Male; PinHeader_2x10_P2.54mm_Vertical

Connections:
1: IC1.1 (D7), J1.1
2: IC1.2 (D6), J1.2
3: IC1.3 (D5), J1.3
4: IC1.4 (D4), J1.4
5: IC1.5 (D3), J1.5
6: IC1.6 (D2), J1.6
7: IC1.7 (D1), J1.7
8: IC1.8 (D0), J1.8
10: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.1, C9.1, IC1.9 (DVDD_1), IC1.10 (DVDD_2), IC1.23 (DVDD_3), IC1.24 (DVDD_4), IC1.25 (DVDD_5), IC1.73 (DVDD_6), IC1.74 (DVDD_7), IC1.79 (DVDD_8), IC1.80 (DVDD_9), J1.9, J1.10, J2.3, J2.4, J2.5, J3.13, J3.14, J3.19, J3.20
11: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, IC1.11 (DGND_1), IC1.12 (DGND_2), IC1.26 (DGND_3), IC1.27 (DGND_4), IC1.28 (DGND_5), IC1.33 (AGND_1), IC1.34 (AGND_2), IC1.39 (AGND_3), IC1.40 (AGND_4), IC1.41 (AGND_5), IC1.45 (AGND_6), IC1.46 (AGND_7), IC1.47 (AGND_8), IC1.53 (AGND_9), IC1.59 (AGND_10), IC1.62 (AGND_11), IC1.66 (AGND_12), IC1.67 (AGND_13), IC1.72 (DGND_6), IC1.75 (DGND_7), IC1.76 (DGND_8), IC1.77 (DGND_9), IC1.78 (DGND_10), IC1.81 (EP), J1.11, J1.12, J2.6, J2.7, J2.8, J2.13, J2.14, J2.19, J2.20, J3.2, J3.6, J3.7, J3.12, J3.15, J3.16, J3.17, J3.18, J4.1, J4.5, J4.6, J4.7, J4.11, J4.19
13: IC1.13 (NC_1), J1.13
14: IC1.14 (A5), J1.14
15: IC1.15 (A4), J1.15
16: IC1.16 (A3), J1.16
17: IC1.17 (A2/IO_RESET), J1.17
18: IC1.18 (A1/SDO), J1.18
19: IC1.19 (A0/SDIO), J1.19
20: IC1.20 (I/O_UD_CLK), J1.20
21: IC1.21 (~WR/SCLK), J2.1
22: IC1.22 (~RD/~CS), J2.2
29: IC1.29 (FSK/BPSK/HOLD), J2.9
30: IC1.30 (OSK), J2.10
31: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, IC1.31 (AVDD_1), IC1.32 (AVDD_2), IC1.37 (AVDD_3), IC1.38 (AVDD_4), IC1.44 (AVDD_5), IC1.50 (AVDD_6), IC1.54 (AVDD_7), IC1.60 (AVDD_8), IC1.65 (AVDD_9), J2.11, J2.12, J2.17, J2.18, J3.5, J4.4, J4.9, J4.13, J4.20
35: IC1.35 (NC_2), J2.15
36: IC1.36 (VOUT), J2.16
42: IC1.42 (VINP), J4.2
43: IC1.43 (VINN), J4.3
48: IC1.48 (IOUT1), J4.8
49: IC1.49 (~IOUT1), J4.10
51: IC1.51 (~IOUT2), J4.12
52: IC1.52 (IOUT2), J4.14
55: IC1.55 (DACBP), J4.15
56: IC1.56 (DAC_RSET), J4.16
57: IC1.57 (NC_3), J4.17
58: IC1.58 (NC_4), J4.18
61: IC1.61 (PLL_FILTER), J3.1
63: IC1.63 (NC_5), J3.3
64: IC1.64 (DIFF_CLK_ENABLE), J3.4
68: IC1.68 (~REFCLK), J3.8
69: IC1.69 (REFCLK), J3.9
70: IC1.70 (S/P_SELECT), J3.10
71: IC1.71 (MASTER_RESET), J3.11

Notes on the sheet:
順番をずらしていることに注意！

Board: 4 copper layers, 40.6 x 40.6 mm, 23 parts (22 on the bottom side), 42 nets.
